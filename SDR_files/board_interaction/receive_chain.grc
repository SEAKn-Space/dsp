options:
  parameters:
    author: SEAKn Space
    description: Copletes Receive chain from rtl-sdr and demodulates correct signal according to signal from AI model.
    generate_options: qt_gui
    id: receive_chain
    output_language: python
    title: Receive Chain
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baseband_LO
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,4
    start: '0'
    step: '100'
    stop: '50_000'
    value: '19_000'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 0435e6
  states: {}
- name: demod_selector
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: BPSK=0, QPSK=1
    min_len: '300'
    orient: QtCore.Qt.Vertical
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hackrf_rate
  id: variable
  parameters:
    value: 20*samp_rate
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '25'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: rtl_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: transmit_freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: baseband_LO
    offset: '0'
    phase: '0'
    samp_rate: rtl_rate/10
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: baseband_LO
    offset: '0'
    phase: '0'
    samp_rate: rtl_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\natha\dsp\SDR_files\test_io\out_File
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod_selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod_selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: demod_selector
    type: complex
  states: {}
- name: bpsk_demod_1
  id: bpsk_demod
  parameters:
    bpsk: bpsk
    nfilts: nfilts
    packet_len: packet_len
    samp_rate: samp_rate
    sps: sps
    thresh: thresh
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: '.35'
    samps_per_sym: '15'
    type: cc
    w: '0.0628'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1.6E3
    win: window.WIN_HAMMING
  states: {}
- name: qpsk_demod_0
  id: qpsk_demod
  parameters:
    packet_len: packet_len
    phase_bw: phase_bw
    qpsk: qpsk
    sps: sps
    thresh: thresh
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    name: '"BPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: rtl_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: 0,0,1,2
    name: '"Input Freq"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: 4,0,1,4
    name: '"Receive After Filter"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(rtl_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    clock_source0: internal
    dc_offset_mode0: '2'
    freq0: carrier_freq
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: rtl_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: centered_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: centered_signal
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_sig_source_x_0_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_selector_1, '0', blocks_file_sink_0, '0']
- [blocks_selector_1_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_selector_3, '0', bpsk_demod_1, '0']
- [blocks_selector_3, '1', qpsk_demod_0, '0']
- [bpsk_demod_1, '0', blocks_selector_1, '0']
- [bpsk_demod_1, '1', blocks_selector_1_0, '0']
- [digital_fll_band_edge_cc_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [qpsk_demod_0, '0', blocks_selector_1, '1']
- [qpsk_demod_0, '1', blocks_selector_1_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', blocks_selector_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
