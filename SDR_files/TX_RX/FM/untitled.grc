options:
  parameters:
    author: SEAKn Space
    generate_options: qt_gui
    id: FM_tx&rx
    output_language: python
    title: FM_tx&rx
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44_100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 44_100*45
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: int(samp_rate/audio_rate)
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '8192'
    name: '"Audio Output Frequencies"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '8192'
    name: '"Modulated FM Signal"'
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    clock_source0: internal
    freq0: carrier_freq
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: samp_rate
    samp_rate: samp_rate
    type: fc32
    vga: '25'
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_freq_sink_x_0, '1']
- [analog_wfm_tx_0, '0', analog_wfm_rcv_pll_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [analog_wfm_tx_0, '0', soapy_hackrf_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rtlsdr_source_0, '0', analog_wfm_rcv_pll_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
