options:
  parameters:
    generate_options: hb_qt_gui
    id: qpsk_demod
    output_language: python
    title: qpsk demod
  states: {}

blocks:
- name: analog_feedforward_agc_cc_0_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.55'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: ''
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: packet_len
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: constellation
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: phase_bw
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qpsk
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: sps
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: thresh
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [analog_feedforward_agc_cc_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_1_0, '0']
- [digital_crc32_bb_0_0_0, '0', pad_sink_1, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [pad_source_1, '0', analog_feedforward_agc_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
